<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>20000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_2</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>10000</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>1</value></param>
<param><key>maxsize</key><value>1</value></param>
<param><key>minsize</key><value>1</value></param>
</block>
<block>
<key>dflood_dflood</key>
<param><key>id</key><value>dflood_dflood_0</value></param>
<param><key>addr</key><value>2</value></param>
<param><key>broadcast_interval</key><value>30</value></param>
<param><key>data_to_file</key><value>False</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>errors_to_file</key><value>False</value></param>
<param><key>FEC</key><value>None</value></param>
<param><key>Plt</key><value>120</value></param>
<param><key>Slt</key><value>50</value></param>
<param><key>Ndupl</key><value>2</value></param>
<param><key>Tmax</key><value>65</value></param>
<param><key>Tmin</key><value>5</value></param>
<param><key>my_sink_addr</key><value>0</value></param>
<param><key>R</key><value>2</value></param>
</block>
<block>
<key>digital_hdlc_deframer_bp</key>
<param><key>id</key><value>digital_hdlc_deframer_bp_1</value></param>
<param><key>max</key><value>10</value></param>
<param><key>min</key><value>4</value></param>
</block>
<block>
<key>digital_hdlc_framer_pb</key>
<param><key>id</key><value>digital_hdlc_framer_pb_1</value></param>
</block>
<block>
<key>splash_XCEIVER</key>
<param><key>id</key><value>splash_XCEIVER_0</value></param>
<param><key>rx_gain</key><value>1</value></param>
<param><key>samp_rate</key><value>48000</value></param>
<param><key>tx_gain</key><value>100</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_2</source_block_id><sink_block_id>dflood_dflood_0</sink_block_id><source_key>strobe</source_key><sink_key>ctrl_in</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0_0</source_block_id><sink_block_id>dflood_dflood_0</sink_block_id><source_key>pdus</source_key><sink_key>from_app</sink_key></connection>
<connection><source_block_id>dflood_dflood_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>to_app</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>dflood_dflood_0</source_block_id><sink_block_id>digital_hdlc_framer_pb_1</sink_block_id><source_key>to_radio</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>digital_hdlc_deframer_bp_1</source_block_id><sink_block_id>dflood_dflood_0</sink_block_id><source_key>out</source_key><sink_key>from_radio</sink_key></connection>
<connection><source_block_id>digital_hdlc_framer_pb_1</source_block_id><sink_block_id>splash_XCEIVER_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>splash_XCEIVER_0</source_block_id><sink_block_id>digital_hdlc_deframer_bp_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
